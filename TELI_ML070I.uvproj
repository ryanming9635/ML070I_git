# Keil uVision project TELI_ML070I.uvproj, settings and files
target Target 1 (MCS-51)
  device: MPC82G516A Megawin
  cpu: IRAM(0 - 0xFF) XRAM(0x0-0x3FF) IROM(0 - 0x3FFF) CLOCK(45000000)
  output: ml070i_MRMCU +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Include
  group Source Group 1
    ./: STARTUP.A51 CPU.c etc_eep.c HS_DVRProtocol.c i2c.c keyremo.c main.c monitor.c Printf.c SysPower.c SysTimer.c
